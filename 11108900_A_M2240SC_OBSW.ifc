Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-03-06T10:03:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 06 10:03:57 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{F5B6E7CD-DC7E-464A-8DB5-50A0040E0264}\ifc * Database version: 5507 * Database creation date: Fri Mar 06 10:03:55 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 06 10:03:55 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 06 10:03:55 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 24224020_A_11108900_M2240SC_OBSW, 11108900_A_M2240SC_OBSW:24224020_A_11108900_M2240SC_OBSW:205336
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 24224020_A_11108900_M2240SC_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
